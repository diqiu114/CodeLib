# Keil uVision project STM32F10X_V01.uvprojx, settings and files
target STM32F10X_V01 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: A7190_V01 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --diag_suppress=1296
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Source\STM32F10X_V01.sct
  group Common
    ./Source/: APP_STM32F10X_Start_V01.S APP_Common_V01.C APP_MEM_V01.C APP_STM32F10X_V01.C APP_STM32F10X_USB_V01.C APP_STM32F10X_ASM_V01.S
  group App
    ./Source/: Product_V01.C
  group UG_Common
    ./Source/: UG_STM32F10X_Start_V01.S UG_Common_V01.C UG_STM32F10X_V01.C UG_STM32F10X_USB_V01.C UG_MEM_V01.C UG_STM32F10X_ASM_V01.S
  group UG_App
    ./Source/: UG_V01.c

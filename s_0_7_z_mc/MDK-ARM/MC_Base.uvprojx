# Keil uVision project MC_Base.uvprojx, settings and files
target MC_Base (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S30_MC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,xSYSTEMVIEW,S07S,__CC_ARM,__TARGET_FPU_VFP,__FPU_PRESENT=1,ARM_MATH_CM4,USE_DSP
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Inc/USB;../Src;../Src/USB;../Src/FATFS_NAND;../stm32_modules/comm;../stm32_modules/comm/uart;../stm32_modules/comm/usb;../stm32_modules/protocol;../stm32_modules/storage;../stm32_modules/rtc;../stm32_modules/comm/uart_mvb;../stm32_modules/storage/fatfs;../stm32_modules/adc;../stm32_modules/gpio;../stm32_modules/observer;../Middlewares/Third_Party/FatFs/src/option;../Src/alarm;../stm32_modules/comm/uart_eth;../Inc/Peripherals/S07S;../Inc/Peripherals;../Src/S07S;../stm32_modules/comm/RS485;../Src/SV/Config;../Src/SV/Sample/FreeRTOSV10/Config;../Src/SV/SEGGER;../Src/SV/Sample/FreeRTOSV10;../Src/S07S/batt_cap;../stm32_modules/storage/EEPROM;../stm32_modules/modbus;../Src/S07S/Alarm_state;../stm32_modules;../Drivers/CMSIS/DSP/Include
  asm include: ..\\Inc;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ./: startup_stm32f427xx.s
    ../Src/: defines.h data_type.h class_init.cpp usb_comm.cpp main.cpp my_tasks.cpp batt_data.cpp hist_data_store.cpp alarm_data_store.cpp alarm.cpp proj_eth_define.h mem_malloc.c debug.c logger.c crc32.c de_protocol.c iap.c protocol_handle.c main.c gpio.c freertos.c adc.c dma.c user_diskio.c fatfs.c fmc.c iwdg.c rtc.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
    ../stm32_modules/rtc/: rtc_ops.cpp
  group Src/Peripherals
    ../Src/Peripherals/: fatfs.c iwdg.c rtc.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c fmc.c
  group S07S/Src
    ../Src/: rs485_data_tranceiver.cpp
    ../Src/S07S/Alarm_state/: alarm_state.cpp
    ../Src/S07S/: callback_it.cpp cell_comm.cpp proj_alarm_store.cpp proj_batt_alarm.cpp proj_batt_data.cpp proj_class_init.cpp proj_eth_proto.cpp proj_paras.cpp proj_tasks.cpp proj_usb_process.cpp proj_def.h s07y_upload_data.cpp mvb_app.cpp
  group S07S/modules
    ../stm32_modules/comm/RS485/: bsp_rs485.c rs485.cpp rs485_with_protocol.cpp
    ../stm32_modules/protocol/: dfs_proto.cpp eth_module_proto.cpp mvb_module_proto.cpp
    ../stm32_modules/observer/: batt_data_subject.cpp alarm_data_subject.cpp trdp_data_subject.cpp
    ../stm32_modules/storage/fatfs/: paras_file.cpp file.cpp
    ../stm32_modules/gpio/: gpi.cpp
    ../stm32_modules/comm/usb/: usb_tranceiver.cpp
    ../stm32_modules/adc/: adc_acq.cpp adc_app.cpp eng_calib.cpp eng_transfer.cpp filter.cpp sar_adc.cpp
    ../stm32_modules/storage/EEPROM/: eeprom_f4xx.c eeprom_flag.cpp eeprom_store.cpp
    ../stm32_modules/modbus/: modbus_master.cpp
    ../stm32_modules/buffer/: double_buffer.cpp circular_buffer.cpp
    ../stm32_modules/comm/: Double_buffered_comm.cpp
    ../stm32_modules/comm/uart/: stm32_uart.cpp
    ../stm32_modules/hw_interface/gpio/: stm32_gpio.cpp
    ../stm32_modules/iap/: flash_if_f407x.cpp
    ../stm32_modules/soc/: self_discharge.cpp batt_cap.cpp batt_cap_adj.cpp batt_cap_init.cpp discharge_data_collector.cpp discharged_cap_record.cpp
    ../stm32_modules/data_convert/: polynomial6.cpp polynomial1.cpp polynomial3.cpp
    ../stm32_modules/comm/uart_eth/: eth_board.cpp single_trdp_module.cpp trdp_module.cpp
    ../stm32_modules/soc/charge/: charge_effi_method.cpp recharge_method.cpp
    ../stm32_modules/soc/discharge/ah_method/: ah_method_discharge.cpp batt_cme.cpp
    ../stm32_modules/comm/uart_mvb/: mvb_module.cpp
    ../stm32_modules/storage/stm32flash/: bsp_flash.c storage.c
  group S07S/Peripherals
    ../Src/Peripherals/S07S/: usart.c adc.c crc.c dma.c gpio.c tim.c stm32f4xx_it.cpp
    ../Src/Peripherals/: pvd.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rng.c stm32f4xx_hal_crc.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/Peripherals/: system_stm32f4xx.c
    ../Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: unicode.c syscall.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Src/USB
    ../Src/USB/: usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.cpp
  group FATFS_NAND
    ../Src/FATFS_NAND/: nand_driver.cpp user_diskio.c my_stm32_ftl.cpp
  group SystemView
    ../Src/SV/Sample/FreeRTOSV10/: SEGGER_SYSVIEW_FreeRTOS.c
    ../Src/SV/Sample/FreeRTOSV10/Config/: SEGGER_SYSVIEW_Config_FreeRTOS.c
    ../Src/SV/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
target S07R (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: S30_MC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,xSYSTEMVIEW,S07R,__CC_ARM,__TARGET_FPU_VFP,__FPU_PRESENT=1,ARM_MATH_CM4,USE_DSP
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Inc\USB;..\Src;..\Src\USB;..\Src\FATFS_NAND;..\stm32_modules\comm;..\stm32_modules\comm\uart;..\stm32_modules\comm\usb;..\stm32_modules\protocol;..\stm32_modules\storage;..\stm32_modules\rtc;..\stm32_modules\comm\uart_mvb;..\stm32_modules\protocol;..\stm32_modules\storage\fatfs;..\stm32_modules\adc;..\stm32_modules\gpio;..\stm32_modules\observer;..\Middlewares\Third_Party\FatFs\src\option;..\Src\alarm;..\stm32_modules\comm\uart_eth;..\Inc\Peripherals\S07S;..\Inc\Peripherals;..\Src\S07S;..\stm32_modules\comm\RS485;..\stm32_modules\comm\uart_mvb;..\Src\SV\Config;..\Src\SV\Sample\FreeRTOSV10\Config;..\Src\SV\SEGGER;..\Src\SV\Sample\FreeRTOSV10;..\Src\S07S\batt_cap;..\stm32_modules\storage\EEPROM;..\stm32_modules\modbus;..\Src;..\stm32_modules\comm\uart_eth;..\Src\S07S\Alarm_state;..\stm32_modules;..\Drivers\CMSIS\DSP\Include
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target S07W (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: S30_MC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,xSYSTEMVIEW,S07W,__CC_ARM,__TARGET_FPU_VFP,__FPU_PRESENT=1,ARM_MATH_CM4,USE_DSP
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Inc\USB;..\Src;..\Src\USB;..\Src\FATFS_NAND;..\stm32_modules\comm;..\stm32_modules\comm\uart;..\stm32_modules\comm\usb;..\stm32_modules\protocol;..\stm32_modules\storage;..\stm32_modules\rtc;..\stm32_modules\comm\uart_mvb;..\stm32_modules\protocol;..\stm32_modules\storage\fatfs;..\stm32_modules\adc;..\stm32_modules\gpio;..\stm32_modules\observer;..\Middlewares\Third_Party\FatFs\src\option;..\Src\alarm;..\stm32_modules\comm\uart_eth;..\Inc\Peripherals\S07W;..\Inc\Peripherals;..\Src\S07W;..\stm32_modules\comm\RS485;..\stm32_modules\comm\uart_mvb;..\Src\SV\Config;..\Src\SV\Sample\FreeRTOSV10\Config;..\Src\SV\SEGGER;..\Src\SV\Sample\FreeRTOSV10;..\Src\S07W\batt_cap;..\stm32_modules\storage\EEPROM;..\stm32_modules\modbus;..\Src;..\stm32_modules\comm\uart_eth;..\Src\S07W\Alarm_state;..\stm32_modules;..\Drivers\CMSIS\DSP\Include
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target S07T (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: S30_MC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,xSYSTEMVIEW,S07S,__CC_ARM,__TARGET_FPU_VFP,__FPU_PRESENT=1,ARM_MATH_CM4,USE_DSP,S07T
  c include: as above
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target S07Z (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: S07Z +hex
  AfterMake: fromelf --bin --output .\Upgrade\S07Z.bin .\S30\S07Z.axf
  AfterMake: .\Upgrade\generate.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,xSYSTEMVIEW,S07S,__CC_ARM,__TARGET_FPU_VFP,__FPU_PRESENT=1,ARM_MATH_CM4,USE_DSP,S07Y,S07Z
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Inc\USB;..\Src;..\Src\USB;..\Src\FATFS_NAND;..\stm32_modules\comm;..\stm32_modules\comm\uart;..\stm32_modules\comm\usb;..\stm32_modules\protocol;..\stm32_modules\storage;..\stm32_modules\rtc;..\stm32_modules\comm\uart_mvb;..\stm32_modules\protocol;..\stm32_modules\storage\fatfs;..\stm32_modules\adc;..\stm32_modules\gpio;..\stm32_modules\observer;..\Middlewares\Third_Party\FatFs\src\option;..\Src\alarm;..\stm32_modules\comm\uart_eth;..\Inc\Peripherals\S07S;..\Inc\Peripherals;..\Src\S07S;..\stm32_modules\comm\RS485;..\stm32_modules\comm\uart_mvb;..\Src\SV\Config;..\Src\SV\Sample\FreeRTOSV10\Config;..\Src\SV\SEGGER;..\Src\SV\Sample\FreeRTOSV10;..\Src\S07S\batt_cap;..\stm32_modules\storage\EEPROM;..\stm32_modules\modbus;..\Src;..\stm32_modules\comm\uart_eth;..\Src\S07S\Alarm_state;..\stm32_modules;..\Drivers\CMSIS\DSP\Include;..\stm32_modules\storage\stm32flash;..\Src\Peripherals
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.2.0, CMSIS:CORE 5.5.0, CMSIS:DSP 1.6.0, CMSIS:DSP 1.7.0, CMSIS:DSP 1.9.0-dev
